<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MAQUINA_DE_ESTADOS.ewp</path>
  </project>
  <batchBuild />
</workspace>
